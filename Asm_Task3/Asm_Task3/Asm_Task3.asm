.include "m16def.inc"
.dseg

.cseg
.org 0

RESET:
	LDI	R16,HIGH(RAMEND)
	OUT SPH, R16
	LDI R16,LOW(RAMEND)
	OUT SPL, R16
	LDI R16, 0XFF
	OUT DDRD,R16
	OUT DDRC,R16
	OUT DDRD,R16
	LDI R16,0b01000000
	OUT ADMUX, R16
	LDI R16,0b11011111
	OUT ADCSRA, R16
	IN R17,ADCL
	IN R18,ADCH
	LDI R22, 0X10
	;AND R17,R22
	;BREQ NUM1
	RCALL RESET

NUM1:
	LDI R18,0XFF
	OUT PORTD,R18
	RCALL WAIT
	LDI R18,0X00
	OUT PORTD,R18
WAIT:
	LDI R19,0XFF
LOOP1:
	LDI R20,0X15
LOOP2:
	LDI R21,0X10
LOOP3:
	DEC R21
	BREQ LOOP3
	DEC R20
	BREQ LOOP2
	DEC R19
	BREQ LOOP1
	RET

